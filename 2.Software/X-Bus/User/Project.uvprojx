# Keil uVision project Project.uvprojx, settings and files
target GD32E230C_EVAL (6160000::V6.16::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E230C_EVAL
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\CORE\Include;..\Drivers\CMSIS\GD\GD32E23x\Include;..\Drivers\CMSIS\GD\GD32E23x\Source\ARM;..\FWLIB\Include;..\User;..\CORE\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CORE
    ../CORE/Source/: tim_pwm.c nrf24l01.c
  group DRIVERS
    ../Drivers/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
    ../Drivers/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group FWLIB
    ../FWLIB/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group USER
    ./: gd32e23x_it.c main.c systick.c
  group DOC
    ./: readme.txt
software components: CMSIS:CORE 5.0.2
